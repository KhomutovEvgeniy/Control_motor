# Keil uVision project newprj.uvproj, settings and files
target newprj (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F103C6 STMicroelectronics
  cpu: IRAM(0x20000000-0x200027FF) IROM(0x8000000-0x8007FFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: output.elf +hex
  c flags: Optim=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c misc: --c99 --feedback=filename
  c include: .\source\;.\source\CMSIS\CM3\CoreSupport;.\source\CMSIS\CM3\DeviceSupport\ST\STM32F10x;.\source\STM32F10x_StdPeriph_Driver\inc;.\source\STM32F10x_StdPeriph_Driver\src;.\source\STM32F10x_StdPeriph_Driver
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x2800
  link misc: --feedback=filename
  group cmsis
    ./source/CMSIS/CM3/CoreSupport/: core_cm3.c
    ./source/CMSIS/CM3/DeviceSupport/ST/STM32F10x/: stm32f10x.h system_stm32f10x.c
    ./source/CMSIS/CM3/DeviceSupport/ST/STM32F10x/startup/arm/: startup_stm32f10x_md.s
    ./: STM32DBG.ini
  group std_periph_lib
    ./source/STM32F10x_StdPeriph_Driver/: stm32f10x_conf.h
    ./source/STM32F10x_StdPeriph_Driver/src/: stm32f10x_rcc.c stm32f10x_gpio.c misc.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_adc.c stm32f10x_dma.c stm32f10x_flash.c stm32f10x_iwdg.c stm32f10x_exti.c stm32f10x_spi.c
  group main_code
    ./source/: main.c
  group adc
    ./source/adc/: adc.c adc.h
  group debug
    ./source/debug/: debug.c debug.h
  group motor_voltage
    ./source/motor_voltage/: motor_voltage.c motor_voltage.h
  group motor_speed
    ./source/motor_speed/: motor_speed.c motor_speed.h
  group control
    ./source/control/: control.c control.h
